# Keil uVision project Gimbal_V1.1.uvprojx, settings and files
target Gimbal_V1.1 (6160000::V6.16::ARMCLANG)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: DarkGimbal +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_HAL_DRIVER,STM32F405xx,TWITCH_GIMBAL_USE_CPP_MAIN
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../RM2023_Lib_V1.2;../Control;../CH010;../Motor_Lib;../Math_Lib;../App_Lib
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group RB_Lib
    ../RM2023_Lib_V1.2/: communication.c communication.h CP_System.c CP_System.h RM_Lib.cpp RM_Lib.h
    ../CH010/: example_data.c example_data.h hipnuc_dec.c hipnuc_dec.h nmea_dec.c nmea_dec.h
  group Motor_Lib
    ../Motor_Lib/: DM.cpp DM.h RM.cpp RM.h RMD.cpp RMD.h
  group Math_Lib
    ../Math_Lib/: PID.cpp PID.h SMC.cpp SMC.h
  group Control_Lib
    ../Control/: Pitch.cpp Pitch.h Shoot.cpp Shoot.h Yaw.cpp Yaw.h
  group App_Lib
    ../App_Lib/: app_gimbal.cpp app_gimbal.h main.cpp
software components: CMSIS:CORE 5.6.0
